# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Library_Inh;.\Start_Inh;.\Uer_Inh;.\System
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start_ins
    ./Start_Ins/: startup_stm32f10x_hd.s
  group Start_Inh
    ./Start_Inh/: core_cm3.h stm32f10x.h system_stm32f10x.h
  group Start_Inc
    ./Start_Inc/: core_cm3.c system_stm32f10x.c
  group System
    ./System/: Delay.c Delay.h
  group Library_Inh
    ./Library_Inh/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Library_Inc
    ./Library_Inc/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User_Inh
    ./Uer_Inh/: stm32f10x_conf.h stm32f10x_it.h buzzer.h LED_Sensor.h LED.h OLED.h OLED_Font.h Timer.h PWM.h Servo.h Key.h Motor.h IC.h
  group User_Inc
    ./User_Inc/: main.c stm32f10x_it.c buzzer.c LED_Sensor.c LED.c OLED.c Timer.c PWM.c Servo.c Key.c Motor.c IC.c
